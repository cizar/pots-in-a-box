# Repository cizar/pots-in-a-box (continued)

## KiCad design hardware/kicad/pots-in-a-box.kicad_pcb (continued)

Board: 2 copper layers, 122 parts (0 on the bottom side), 100 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3

File hardware/bom.csv:

"Refs","Value","Footprint","Qty","Description"
"C1","470uF 25V","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm","1",""
"C2,C4,C12,C13,C14,C15,C22,C23,C30,C104,C105,C106,C204,C205,C206","100nF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","15","AVCC decoupling,Auto-reset for Optiboot,Decoupling,Guard time,VCC decoupling"
"C3","330nF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C5","10uF 16V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","1",""
"C6","100uF 100V","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm","1",""
"C10,C11","22pF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","2",""
"C20,C21","10uF 25V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","2","Bootstrap capacitor"
"C24","100nF 100V","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C101,C201","2.2uF 250V","Capacitor_THT:C_Rect_L18.0mm_W8.0mm_P15.00mm_FKS3_FKP3","2","Film coupling capacitor (NC side)"
"C102,C103,C202,C203","47nF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","4",""
"D1","1N5822","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","1","Reverse-polarity protection"
"D2","PWR","LED_THT:LED_D3.0mm","1","Power LED (panel)"
"D10","CALL","LED_THT:LED_D3.0mm","1","Call-active LED (panel)"
"D20,D21","UF4007","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","2","Bootstrap diode"
"D101,D103,D104,D201,D203,D204","1N4148","Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal","6","Antiparallel to the opto LED,Clamp to +5 V,Clamp to GND"
"D102,D202","P6KE68CA","Diode_THT:D_DO-15_P10.16mm_Horizontal","2","Line TVS"
"F1","PTC 1.1A","Fuse:Fuse_Bourns_MF-RG300","1",""
"F101,F201","PTC 100mA","Fuse:Fuse_Bourns_MF-RG300","2",""
"J1","12V 2A","Connector_BarrelJack:BarrelJack_Horizontal","1","Pin 1 = centre (+). External certified 12 V wall adapter: no mains inside the box."
"J2","BOOST_MODULE","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-4-5.08_1x04_P5.08mm_Horizontal","1","Boost module: 1 IN+, 2 IN-, 3 OUT+ (V_LINE 24-48 V), 4 OUT-. To be replaced by an on-board boost after the bench test."
"J3","ISP","Connector_IDC:IDC-Header_2x03_P2.54mm_Vertical","1","ISP. MISO is PB4, shared with COUNTRY_SW through R11 (ISP-safe)."
"J4","FTDI","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical","1","USB-serial (FTDI-style): 1 GND, 2 CTS, 3 VCC, 4 TXD (to MCU RX), 5 RXD (from MCU TX), 6 DTR"
"J101,J201","RJ11","Connector_RJ:RJ12_Amphenol_54601-x06_Horizontal","2","Line jack (6P footprint): centre pair 3/4 = RING/TIP"
"K3,K101,K201","HK19F-DC12V-SHG","Relay_THT:Relay_DPDT_Omron_G5V-2","3","Link relay: joins the line-side audio nodes during a call,Ring relay (DPDT)"
"Q3,Q4,Q5,Q6","IRF540N","Package_TO_SOT_THT:TO-220-3_Vertical","4",""
"Q7","BC547","Package_TO_SOT_THT:TO-92_Inline","1","Inverter: leg B gets the complement of RING_DRIVE"
"Q101,Q201","MJE340","Package_TO_SOT_THT:TO-126-3_Vertical","2","Pass transistor, 300 V, small heatsink"
"Q102,Q202","BC546","Package_TO_SOT_THT:TO-92_Inline_Wide","2",""
"R1","4k7 1W","Resistor_THT:R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal","1","V_LINE bleeder"
"R2,R11,R103,R104,R105,R109,R110,R111,R112,R203,R204,R205,R209,R210,R211,R212","1k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","16",""
"R10,R13,R25","10k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","3","Keeps the bridge defined during reset/ISP"
"R12","470","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","1",""
"R20","470 5W","Resistor_THT:R_Axial_Power_L25.0mm_W6.4mm_P27.94mm","1","R_BRIDGE: limits short-circuit and shoot-through current"
"R21,R22,R23,R24","22","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","4",""
"R26,R106,R206","4k7","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","3",""
"R101,R201","10k 1/2W","Resistor_THT:R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal","2",""
"R102,R202","27","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","2","R_SENSE: 0.65 V / 27 = 24 mA"
"R107,R108,R207,R208","100k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","4","Gain = 1"
"R113,R213","300k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","2","Guard time"
"RV101,RV201","47k","Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical","2","Tone level"
"SW1","AR/US","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","Panel switch: open = AR, closed = US"
"U1","L7805","Package_TO_SOT_THT:TO-220-3_Vertical","1",""
"U2","ATmega328P-P","Package_DIP:DIP-28_W7.62mm_Socket","1",""
"U3,U4","IR2104","Package_DIP:DIP-8_W7.62mm","2",""
"U5","ULN2003A","Package_DIP:DIP-16_W7.62mm","1",""
"U101,U201","PC817","Package_DIP:DIP-4_W7.62mm","2",""
"U102,U202","MT8870","Package_DIP:DIP-18_W7.62mm","2",""
"Y1","16MHz","Crystal:Crystal_HC49-4H_Vertical","1",""
"Y101,Y201","3.579545MHz","Crystal:Crystal_HC49-4H_Vertical","2",""
